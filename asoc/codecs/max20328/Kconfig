## asoc/codecs/max20328/Kconfig
```kconfig
#
# Maxim Integrated Product Sensors
#
config SWITCH_MAX20328
	bool "zte add MAX20328"
```
